# IAR project Esercizio 10.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\itama\Desktop\Laboratorio di Misure a Microcontrollore\Esercizi\Esercizio Interrput 01; C:\Users\itama\Desktop\Laboratorio di Misure a Microcontrollore\Esercizi\Esercizio Interrput 01\Libreria
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Esercizio 10.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c MySTM32F303VC.h
    Libreria/: startup_stm32f30x.s system_stm32f30x.c
