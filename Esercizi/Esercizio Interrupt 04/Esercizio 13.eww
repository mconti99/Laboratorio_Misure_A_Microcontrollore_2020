<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Esercizio 13.ewp</path>
    </project>
    <batchBuild />
</workspace>
